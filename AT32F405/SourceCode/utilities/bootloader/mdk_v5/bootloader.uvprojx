# Keil uVision project bootloader.uvprojx, settings and files
target at_start_f405 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F405RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.0.9
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader_405 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F405RCT7,USE_STDPERIPH_DRIVER,AT_START_F405_V1,USB_OTG_HS
  c include: ..\..\..\libraries\cmsis\cm4\core_support;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\drivers\inc;..\..\..\project\at32f402_405_board;..\..\..\middlewares\usb_drivers\inc;..\..\..\middlewares\usbd_class\hid_iap;..\inc
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x19800
  group user
    ../src/: at32f402_405_clock.c at32f402_405_int.c main.c hid_iap_user.c wk_system.c
  group bsp
    ../../../project/at32f402_405_board/: at32f402_405_board.c
  group firmware
    ../../../libraries/drivers/src/: at32f402_405_acc.c at32f402_405_crm.c at32f402_405_debug.c at32f402_405_exint.c at32f402_405_gpio.c at32f402_405_flash.c at32f402_405_misc.c at32f402_405_pwc.c at32f402_405_usart.c at32f402_405_usb.c at32f402_405_crc.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/: system_at32f402_405.c
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f402_405.s
  group usbd_driver
    ../../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../../../middlewares/usbd_class/hid_iap/: hid_iap_class.c hid_iap_desc.c
  group readme
    ../: readme.txt
target at_start_f402 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F402RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.0.9
  output: bootloader_402 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F402RCT7,USE_STDPERIPH_DRIVER,AT_START_F402_V1,USB_OTG_FS
  c include: ..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\project\at32f402_405_board;..\..\..\..\..\middlewares\usb_drivers\inc;..\..\..\..\..\middlewares\usbd_class\hid_iap;..\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
